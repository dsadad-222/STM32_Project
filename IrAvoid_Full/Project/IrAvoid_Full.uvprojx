# Keil uVision project IrAvoid_Full.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IrAvoid_Full +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Arm_Kernel;..\STM32_Library\inc;..\App_User;..\Drv_Common
  asm include: ..\Arm_Kernel;..\STM32_Library\inc;..\App_User;..\Drv_Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Arm_Kernel
    ../Arm_Kernel/: core_cm3.c system_stm32f10x.c
  group App_User
    ../App_User/: main.c stm32f10x_it.c
  group STM32_Library
    ../STM32_Library/src//: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drv_Common
    ../Drv_Common/: led_drv.c beep_drv.c usart_drv.c systick_drv.c oled_drv.c flash_drv.c font8x8.c adc_drv.c cn_font16.c key_drv.c pwm_drv.c w25q64_drv.c hcsr04_drv.c ir_drv.c
